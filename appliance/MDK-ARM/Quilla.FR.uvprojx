# Keil uVision project Quilla.FR.uvprojx, settings and files
target Quilla.FR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F040CxB Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08007000,0x00019000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Quilla.FR +hex
  AfterMake: fromelf --bin -o "$L\Quilla.FR.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,PY32F040xB,QAPP_BUILD
  c include: ..\Inc;..\Drivers\BSP\PY32F040xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F040\Include;..\Drivers\PY32F040_HAL_Driver\Inc;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x19000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Src/: system_py32f040.c
    ./: startup_py32f040xx.s
  group Application/User
    ../Src/: main.c recver.c led.c app_qboot_meta.c app_qboot_secver.c py32f040_hal_msp.c py32f040_it.c
  group Drivers/PY32F040_HAL_Driver
    ../Drivers/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_cortex.c py32f040_hal_dma.c py32f040_hal_gpio.c py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_uart.c py32f040_hal_flash.c py32f040_hal_pwr.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 6.1.1
